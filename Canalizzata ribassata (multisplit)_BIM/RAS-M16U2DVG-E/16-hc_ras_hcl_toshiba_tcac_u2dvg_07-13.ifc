Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [DesignTransferView_V1.0]
File name: Project Number
Time: 2019-05-28T11:16:09
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue May 28 11:16:09 2019 * Host: DS-SGH818S545 * Database: C:\Users\KAVYAS~1\AppData\Local\Temp\{26A03FD3-9F65-4141-8E6E-53AEBEA68EAE}\ifc * Database version: 5507 * Database creation date: Tue May 28 11:16:07 2019 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Tue May 28 11:16:08 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue May 28 11:16:08 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 ft

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 ft

# IfcBuildingElementProxy: RAS-M07U2DVG-E, 16-HC_RAS_HCL_TOSHIBA_RAS_U2DVG_07-13:RAS-M07U2DVG-E:259098
In: Level 1
Type - Material: Glass, Colour RGB-255 255 255, Colour RGB-250 000 000
Pset_ManufacturerTypeInformation - Manufacturer: Toshiba
Pset_BuildingElementProxyCommon - Reference: RAS-M07U2DVG-E; IsExternal: no
